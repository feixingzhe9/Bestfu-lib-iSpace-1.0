# Keil uVision project Switch.uvprojx, settings and files
target Target (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ASP3-2_V30000 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c include: ..\Core;..\Lib_code\SysHard\inc;..\Lib_code\SysLib\inc;..\User;..\Lib_code\App;..\User\drive;..\User\unit;..\User\attr
  memory RVCT4: ROM 0x8006400 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Core/: system_stm32f10x.c startup_stm32f10x_md.s
  group SysLib
    ../Lib_code/SysLib/: AttrEncrypt .c BestFuLib.c CMDProcess.c Command.c CRC.c Delay.c DeviceIDSetAttr.c DevPartTab.c DlyAttrProcess.c EEPROM.c FaultManage.c Fifo.c FlashAttr.c Group.c GroupData.c LinkScanFifo.c Linksimplest.c LinksimplestTime.c Linksrc.c LinkWRDC.c MsgPackage.c Object.c Scene&Group.c Sign433.c Sign433Attr.c SysExeAttr.c SysTestAttr.c Thread.c TimeHandle.c UnitShare_Attr.c Updata.c Upload.c UserData.c UserDataDownload.c Encode_lib.lib
  group SysHard
    ../Lib_code/SysHard/: DeviceReset.c Flash.c Gpio.c I2C.C Instruct.c Program.c SI4432.c SPI.c Sys.c SysHard.c SysTick.c Test.c Usart.c WDG.c
  group APP
    ../Lib_code/App/: main.c UnitCfg.c
  group Drive
    ../User/drive/: relay.c Led.c WTC6104BSI.c
  group Unit
    ../User/unit/: KeyUnit.c LedUnit.c SwitchUnit.c
  group Attr
    ../User/attr/: SwitchAttr.c KeyAttr.c
  group Readme
    ../: Readme.txt
